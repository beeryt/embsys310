<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\stm32mxcube\project\EWARM\project.ewp</path>
    </project>
    <batchBuild />
</workspace>
