<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\blink.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\endian.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\func.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\stack.ewp</path>
    </project>
    <batchBuild />
</workspace>
