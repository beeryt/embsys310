<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\problem1.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\problem2.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\problem3.ewp</path>
    </project>
    <batchBuild />
</workspace>
