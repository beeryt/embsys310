# IAR project problem1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L475VG ST STM32L475VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: C:\Users\Carl\Desktop\UW_Workspace\embsys310\assignment06\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: problem1.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../: problem1.c
